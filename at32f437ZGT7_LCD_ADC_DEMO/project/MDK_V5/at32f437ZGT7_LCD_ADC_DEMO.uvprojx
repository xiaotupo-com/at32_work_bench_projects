# Keil uVision project at32f437ZGT7_LCD_ADC_DEMO.uvprojx, settings and files
target at32f437ZGT7_LCD_DEMO (6160000::V6.16::ARMCLANG)
  device: -AT32F437ZGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.5
  cpu: IRAM(0x20000000,0x18000000) IROM(0x08000000,0x40000000F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f437ZGT7_LCD_ADC_DEMO +hex
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: AT32F437ZGT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\bsp\st7789;..\..\xtp;..\..\bsp\buzzer;..\..\bsp\ACS712
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_gpio.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_adc.c at32f435_437_spi.c at32f435_437_dma.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_misc.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group st7789
    ../../bsp/st7789/: st7789.cpp st7789.h fonts.c
  group xtp
    ../../xtp/: xtp_printf.cpp xtp_sort.cpp xtp_sort.h xtp_delay.cpp xtp_utility.cpp
  group buzzer
    ../../bsp/buzzer/: buzzer.cpp buzzer.h
  group bsp
    ../../xtp/: xtp_gpio.cpp
    ../../bsp/ACS712/: acs712.cpp
